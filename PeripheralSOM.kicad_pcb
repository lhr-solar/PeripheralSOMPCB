# Repository lhr-solar/PeripheralSOMPCB (continued)

## KiCad design BPS-PeripheralSOM.kicad_pcb

Board: 4 copper layers, 40.0 x 50.0 mm, 111 parts (61 on the bottom side), 77 nets.

Parts:
C7, C10, C11, C12, C14, C15, C16, C17, C18, C25, C31, C32, C35, C36: 100nF; C_0805_2012Metric
C13, C43: 4.7uF; C_0805_2012Metric
C19: 22uF; C_0805_2012Metric
C20, C23, C24, C33: 10uF; C_0805_2012Metric
C21, C22: 12p; C_0805_2012Metric
C26: 47nF; C_0805_2012Metric
C34: 12.5 nF; C_0805_2012Metric
C39: 4.7 nF; C_0805_2012Metric
C44: 0.1uF; C_0805_2012Metric
CR1, CR2: D5V0P4UR6SO-7
D1, D3: 12V; LED_0805_2012Metric
D2: SD12_SOD323; D_SOD-323
D4: Heartbeat; LED_0805_2012Metric
D5: 3.3V; LED_0805_2012Metric
D6: 5V; LED_0805_2012Metric
D7: 6V; MMDL101T1G
D8: SP0503BAHT; SOT-143
D9: Vbus; LED_0805_2012Metric
D11: D_Schottky; D_SOD-323_HandSoldering
D12, D13, D14, D15: LED; LED_0805_2012Metric
FB4: FerriteBead; L_0805_2012Metric
IC1: TPS1120DR
IC2: TLV70130DBVR
J1: SWD; PinHeader_1x04_P2.54mm_Vertical
J2, J5: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J4: 52465-2470; 524652470
JP3: Termination Resistors; PinHeader_1x02_P2.54mm_Vertical
L1: 4.7uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
LOGO1: Dr. Hallock; Hallock_Image_Small
LOGO2: UTSVT Logo; UTSVT_Logo_Symbol
LOGO3: LHRs Logo; LHRs_LOGO
MH1, MH4: M.3; MountingHole_3mm
MH2, MH3: M.3; MountingHole_3.2mm_M3
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
R2, R8, R9, R10, R19, R23, R29, R44: 10K; R_0805_2012Metric
R3, R28, R39: 22.1k; R_0805_2012Metric
R4: 100k; R_0805_2012Metric
R5, R15, R41: 1k; R_0805_2012Metric
R6, R11, R14, R17, R18, R21, R26, R32: 2.2k; R_0805_2012Metric
R7: 400; R_0805_2012Metric
R12, R24, R25: 10k; R_0805_2012Metric
R13: 200; R_0805_2012Metric
R20: 402k; R_0805_2012Metric
R22: 120; R_0805_2012Metric
R27: 20K; R_0805_2012Metric
R31, R33: 5.1k; R_0805_2012Metric
R40: 47.5k; R_0805_2012Metric
SW1: Reset; SW_SPST_B3SL-1002P
TP1, TP4, TP7, TP8, TP9: TestPoint; TestPoint_HEX_3mmID
TP3, TP6: TestPoint; PinHeader_1x01_P2.54mm_Vertical
U1: STM32L431CBTx; LQFP-48_7x7mm_P0.5mm
U2: TPS5405DR
U3: CDSOT23-T24CAN
U4: TCAN337; TCAN337DCNR
U5: CP2102N-Axx-xQFN24; CP2102N-A02-GQFN24
U6: TPS2115APW
U7: LM76202QPWPRQ1
Y1: 8M; Crystal_SMD_TXC_7A-2Pin_5x3.2mm

Connections:
+3.3V: C10.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C32.1, CR1.5, CR2.5, FB4.1, IC1.1 (1SOURCE), IC1.3 (2SOURCE), IC2.1 (OUT), J1.1, J4.2, J4.9, R2.1, R4.1, R8.1, R14.1, R23.1, R25.1, R29.1, TP4.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.3 (VCC)
+3V3: C43.1, C44.1, R41.1, U5.5 (VIO), U5.6 (VDD), U5.7 (VREGIN)
+5V: C19.1, C35.1, L1.2, R21.1, TP9.1, U2.5 (VSENSE), U6.8 (IN1)
+12V: C23.1, C33.1, R3.1, R24.1, TP1.1, U2.2 (VIN), U7.15 (OUT_1), U7.16 (OUT_2)
/12V_Ext: C20.1, D2.2 (A2), J4.22, R12.1, R28.1, TP3.1, U7.1 (IN_1), U7.2 (IN_2)
/CAN/Fault: R25.2, R26.1, U4.5 (FAULT)
/CAN_H: J4.23, R22.2, U3.1 (CAN_H), U4.7 (CANH)
/CAN_L: J4.21, JP3.1 (A), U3.2 (CAN_L), U4.6 (CANL)
/CAN_RX: J2.1, U1.45 (PB8), U4.4 (RXD)
/CAN_TX: J2.2, U1.46 (PB9), U4.1 (TXD)
/I2C1_SCL: J4.14, R8.2, U1.42 (PB6)
/I2C1_SDA: J4.16, R2.2, U1.43 (PB7)
/I2C2_PU_En: R4.2, R5.1, U1.29 (PA8)
/I2C2_SCL: J4.8, R9.2, U1.21 (PB10)
/I2C2_SDA: J4.6, R10.1, U1.22 (PB11)
/NRST: C11.1, R29.2, SW1.1, U1.7 (NRST)
/OSC_IN: C21.1, U1.5 (PH0), Y1.1
/OSC_OUT: C22.1, U1.6 (PH1), Y1.2
/PA0: R11.1, U1.10 (PA0)
/PA1: J4.20, U1.11 (PA1)
/PA2: J4.18, U1.12 (PA2)
/PB3: R18.1, U1.39 (PB3)
/PB4: R17.1, U1.40 (PB4)
/PB5: R6.1, U1.41 (PB5)
/PowerDist/5v_mux: C31.1, IC2.3 (IN), TP8.1, U6.7 (OUT)
/PowerDist/Fault: D3.1 (K), R24.2, U7.14 (~FLT)
/PowerDist/PowerProtection/MODE: R20.1, U7.6 (MODE)
/PowerDist/PowerProtection/OVP: R13.2, R15.1, U7.5 (OVP)
/PowerDist/PowerProtection/RTN: C25.2, R15.2, R20.2, R27.2, U7.8 (RTN), U7.17 (EP)
/PowerDist/PowerProtection/UVLO: R12.2, R13.1, U7.3 (UVLO)
/SPI1_MISO: CR2.1, J4.15, U1.16 (PA6)
/SPI1_MOSI: CR2.6, J4.17, U1.17 (PA7)
/SPI1_NSS: CR2.4, J4.19, U1.14 (PA4)
/SPI1_SCK: CR2.3, J4.13, U1.15 (PA5)
/SPI2_MISO: CR1.1, J4.3, U1.27 (PB14)
/SPI2_MOSI: CR1.6, J4.1, U1.28 (PB15)
/SPI2_NSS: CR1.3, J4.7, U1.25 (PB12)
/SPI2_SCK: CR1.4, J4.5, U1.26 (PB13)
/SWCLK: J1.2, U1.37 (PA14)
/SWDIO: J1.4, U1.34 (PA13)
/USART1_RX: J5.2, U1.31 (PA10), U5.20 (RXD)
/USART1_TX: J5.1, U1.30 (PA9), U5.21 (TXD)
/USB/CC1: J3.A5 (CC1), R31.2
/USB/CC2: J3.B5 (CC2), R33.2
/USB/D+: D8.2 (K), J3.A6 (D+), J3.B6 (D+), U5.3 (D+)
/USB/D-: D8.3 (K), J3.A7 (D-), J3.B7 (D-), U5.4 (D-)
/USB/vbus_in: D11.2 (A), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
/boot: R19.1, U1.44 (PH3)
GND: C10.2, C11.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C39.2, C43.2, C44.2, CR1.2, CR2.2, D1.1 (K), D2.1 (A1), D4.1 (K), D5.1 (K), D6.1 (K), D7.2 (A), D8.1 (A), D9.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), IC2.2 (GND), J1.3, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.4, J4.11, J4.24, NT1.1, R7.2, R19.2, R31.1, R33.1, R40.2, SW1.2, TP6.1, U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.7 (GND), U3.3 (GND), U4.2 (GND), U5.2 (GND), U5.25 (GND), U6.3 (D1), U6.5 (GND)
GNDA: C7.2, C12.2, C15.2, J4.12, NT1.2, U1.8 (VSSA)
unnamed: C39.1, R44.1
unnamed: D1.2 (A), R3.2
unnamed: D3.2 (A), R28.2
unnamed: D4.2 (A), R11.2
unnamed: D5.2 (A), R14.2
unnamed: D6.2 (A), R21.2
unnamed: C26.2, D7.1 (K), L1.1, U2.8 (LX)
unnamed: D9.2 (A), R32.2
unnamed: D12.2 (A), R6.2
unnamed: D13.2 (A), R17.2
unnamed: D14.2 (A), R18.2
unnamed: D15.2 (A), R26.2
unnamed: IC1.7 (1DRAIN_1), IC1.8 (1DRAIN_2), R9.1
unnamed: IC1.2 (1GATE), IC1.4 (2GATE), R5.2
unnamed: IC1.5 (2DRAIN_1), IC1.6 (2DRAIN_2), R10.2
unnamed: JP3.2 (B), R22.1
unnamed: C26.1, U2.1 (BOOT)
unnamed: R44.2, U2.6 (COMP)
unnamed: C34.1, U2.4 (SS)
unnamed: R39.1, R40.1, U5.8 (VBUS)
unnamed: R41.2, U5.9 (~RST)
unnamed: R7.1, U6.4 (ILIM)
unnamed: C25.1, U7.12 (DVDT)
unnamed: R27.1, U7.11 (ILIM)
unnamed: R23.2, U7.7 (~SHDN)
VBUS: C24.1, C36.1, D8.4 (K), D11.1 (K), R32.1, R39.2, TP7.1, U6.6 (IN2)
VDDA: C7.1, FB4.2, J4.10, U1.9 (VDDA)

## Code that names these connections

File CubeMX/CubeMX.ioc (part):

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Mcu.Name=STM32L431C(B-C)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32L431CBTx
PA0.Mode=PGA Connected
PA0.Signal=OPAMP1_VINP
PA1.Mode=PGA Connected
PA1.Signal=OPAMP1_VINM
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=Full_Duplex_Master
PA11.Signal=SPI1_MISO
PA12.Mode=Full_Duplex_Master
PA12.Signal=SPI1_MOSI
PA13\ (JTMS-SWDIO).Mode=Serial_Wire
PA13\ (JTMS-SWDIO).Signal=SYS_JTMS-SWDIO
PA14\ (JTCK-SWCLK).Mode=Serial_Wire
PA14\ (JTCK-SWCLK).Signal=SYS_JTCK-SWCLK
PA15\ (JTDI).Signal=GPIO_Output
PA2.Signal=ADCx_IN7
PA3.Mode=PGA Connected
PA3.Signal=OPAMP1_VOUT
PA4.Signal=ADCx_IN9
PA5.Signal=ADCx_IN10
PA6.Signal=ADCx_IN11
PA7.Signal=GPIO_Output
PA8.Signal=GPIO_Output
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.Mode=NSS_Signal_Hard_Output
PB0.Signal=SPI1_NSS
PB1.Signal=ADCx_IN16
PB10.Mode=Full_Duplex_Master
PB10.Signal=SPI2_SCK
PB11.Signal=GPIO_Output
PB12.Mode=NSS_Signal_Hard_Output
PB12.Signal=SPI2_NSS
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB3\ (JTDO-TRACESWO).Mode=Full_Duplex_Master
PB3\ (JTDO-TRACESWO).Signal=SPI1_SCK
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Mode=CAN_Activate
PB8.Signal=CAN1_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN1_TX
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=80000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2023-06-17 Added library and KiCAD project
2023-06-17 Added USB, CAN (need to change), and the L431CTB peripherals
2023-06-18 Changed bypass cap values and added heirarchical labels
2023-06-19 Fixed libraries
2023-06-24 add power didst
2023-06-24 add ports to power dist
2023-06-24 add reverse polarity to power dist
2023-06-24 added heirarchical labels
2023-06-24 Fixed grid size and heirarcical labels
2023-06-24 Fixed can schematic and added can connector on main sheet
2023-06-24 Added datasheets to PowerDist
2023-06-25 Added I2C pull up resistors and questions
2023-06-25 Added TVS diodes for Vin protection
2023-06-25 removed 5V TVS diode :cry:
2023-06-25 Added some footprints
2023-06-25 Added ferrite beads to power input
2023-06-27 Added LEDs
2023-06-27 Made things look nicer
2023-06-28 Added LEDs and Switches
2023-06-30 Added remaining tasks to do for the board
2023-06-30 Changed layout of the signals in connector
2023-07-02 added more footprints
2023-07-02 added SPI terminating resistors
2023-07-03 switched order or ESD and SPI
2023-07-03 removed side reference circuits
2023-07-04 add 3.3v tvs diode
2023-07-06 Cleaned up schematic and updated to do
2023-07-09 removed .DS_Store and updated .gitignore to not do .DS_Store
2023-07-11 moved the 3.3V label
2023-07-11 Added extra todo stuff from PCB camp
2023-07-11 changed connector layout (moved 12V and pwrgnd next to eachother)
2023-07-14 fixed footprint library and changed connector footprint
2023-07-14 Updated symbols from library + fixed ERC errors
2023-07-14 Fixed more DRC errors
2023-07-14 Updated PCB from schematic + assigned push button footprint
2023-07-16 switch datasheet
2023-07-16 ready for PCB layout
2023-07-17 Seperated components in layout
2023-07-17 USB routing
2023-07-17 STM32 peripheral routing + LED routing
2023-07-17 Started power routing (going to sleep :sob: )
2023-07-17 cleaned up layout now that i have sleep
2023-07-17 finished can layout, need to add Bypass caps layout
2023-07-17 Preliminary layout (for review)
2023-07-19 5V can and moved capacitors to bottom side
2023-07-19 Made layout smaller
2023-07-19 Removed can schematic from main schematic, moved power connectors to power sheet, and reduced layout by a little bit
2023-07-20 changed to isolated 5V converter
2023-07-20 Added pi filter for GNDA
2023-07-20 Added pi filter footprints, and set 50 x 50 mm layout for board
2023-07-20 Added 3D models to PCB file
2023-07-20 Fixed labels for powerdist
2023-07-23 updated todo
2023-07-23 40mm layout
2023-07-23 fixed USB orientaiton
2023-07-24 moxed can terminating jumper to not interfere with connector, added connector 3D models, and updated mating part for SOM connector
2023-07-24 moved can chip to not interfere with connector and add VDDA to SOM connector
2023-07-26 def didn't spend 40 minutes making a rounded edgecut layer
2023-07-26 Begun moving stuff over for layout
2023-07-27 new layout + schematic changes
2023-07-27 fixed edge cut layer for rounded corners
2023-07-27 beggining of the great 1mm migration
2023-07-28 Switched connector back to 2x10 and changed can connector pinout
2023-07-28 Deleted every component and started replacing :p
2023-07-29 redid can and power layout (kill me)
2023-07-30 changed pins around to make routing easier
2023-07-30 Prelim layout v2 final draft (ahhhhhhhhh), also connected GPIO to STDBY and SILENT pins
2023-07-30 redo layout again >>:(
2023-07-30 aligned components
2023-07-31 moved bypass caps and cleaned annotations
2023-07-31 aligned components to .5 mm
2023-07-31 re-oriented i2c pullups to be closer to pins
2023-08-06 added Tianda's suggestions
2023-08-09 added datasheets for passive components
2023-08-10 Updated readme with connectors
2023-08-14 fix debouncing circuit, start routing
2023-08-15 more routing
2023-08-15 started can changes
2023-08-15 fixed DRC errors
2023-08-15 create 3.3 and gnd planes
2023-08-15 Revert "fixed DRC errors"
    This reverts commit 6f8641e750904608ed1900c07ac6419153d0d4bc.
2023-08-15 make one trace prettier
2023-08-15 make traces away from edge
2023-08-19 cleaned up silkscreen, removed unused tracks and vias, and moved canout connectorto main schematic
2023-08-28 switched can_V and 5V, turned power stuff into planes, started moving traces to inner layer. Need to fix DRC errors
2023-08-28 added more part numbers
2023-08-28 added part numbers
2023-09-02 fixed GNDPWR plane
2023-09-02 fixed somConnector and flipped pmos D and S
2023-09-02 Cleaned up silkscreen more and made GND planes more whole
2023-09-07 added more things to BOM and cleaned up silkscreen
2023-09-09 Added more symbols for BOM and started sw pull downs
2023-09-10 added sw pull downs
2023-09-10 Updated BOM with quantites to order
2023-09-12 fixed repeated items in BOMs and made molex connectors not backwards
2023-09-13 Forgot to save BOM changed :skull:
2023-09-13 Set branch to master for kicad library
2023-09-14 made 5V fill more whole, deleted not needed vias, made the vias bigger for bigger traces, changed 5V ferrite fill
2023-09-20 i2c pullup & some fill/zone fixes
2023-09-20 updated BOM
2023-09-20 added step file + changed BOM again
2023-09-23 gerbers
2023-09-23 V1.0 (#1)
    * Added USB, CAN (need to change), and the L431CTB peripherals
    * Changed bypass cap values and added heirarchical labels
    * Fixed libraries
    * add power didst
    * add ports to power dist
    * add ports to power dist
2023-09-23 fix plane under oscillator
2023-09-24 Added PCB image
2023-09-24 fixed spacing
2023-09-26 build fix
2023-10-06 Updated BOM + new .01uF part number
2023-10-17 lakshay stew to go with ishan bone soup
2023-10-17 typo in the readme
2023-10-18 lakshay stew to go with ishan bone soup (#5)
    * lakshay stew to go with ishan bone soup
    * readme
    * typo in the readme
2023-10-18 Updated images for the PCB
2023-10-21 v1.2 initial changes
2023-10-21 Fix broken USB (ノಠ益ಠ)ノ彡┻━┻
2023-11-04 standardize can connector
2023-11-04 add new isolated power:
2023-11-04 started layout and Champers is going to break my laptop
2023-11-11 first draft
2023-11-11 Second commit
2023-11-11 silkscreen updated
2023-11-11 some small fixes
2023-11-14 relayed out usb chips
2023-11-15 fixed layout
2023-11-19 started fixing layout
2023-11-20 revise layout for closer gndpwr plane
2023-11-20 preliminary wiring
2023-11-20 neato
2023-11-20 routed
2023-11-21 silkscreen
2023-11-21 pr template
2023-11-21 update datasheet and footprints
2023-11-21 redone gerbers as a sanity check
2023-11-21 aligned buttons but not capacitors haha @Champers5000
2023-11-21 V1.2a (#6) ( no bom )
    * lakshay stew to go with ishan bone soup
    * readme
    * typo in the readme
    * v1.2 initial changes
    * Fix broken USB (ノಠ益ಠ)ノ彡┻━┻
    * fix power dist from can
2023-12-05 Fixed connector numbers and pinouts on readme
2023-12-05 Added part numbers and BOM
2023-12-05 Added mouser cart
2023-12-05 Fixed Readme spacing
2023-12-05 forgot to add step file :cry:
2024-02-03 whoops, forgot to push :/
2024-03-21 update to kicad 8, fix capacitance multiplier
2024-03-21 nice plump round tears of the sacrificed children in LHR
2024-06-02 Added BOM + Mouser + Docs (#7)
    * Updated Readme
    * fixed schematic name
    * Fixed connector numbers and pinouts on readme
    * Added part numbers and BOM
    * Added mouser cart
    * Fixed Readme spacing
2024-07-28 started pin fixes
2024-07-28 fixed nucleo header
2024-08-20 fixed mcu pins and moved revision history
2024-08-21 started v2 changes
2024-08-21 fixed SPI prot
2024-08-22 wahoooooo
2024-08-22 fixed symbols
2024-08-22 updated footprints and added caps
2024-08-22 deleted powerProt :(
2024-08-23 layout go brrrr
2024-08-24 i can do basic algebra, i promise
2024-08-24 dumbass
2024-08-26 changed pullup
2024-08-26 fault pp
2024-08-26 wahoooooooooooooooooooooooooooooooooooo
2024-08-26 pp foot
2024-08-27 ppppp
2024-08-27 fix SPI prot
2024-08-27 more cap filtering
2024-08-27 hiiiiii pratttttttt
2024-09-03 layout go brrrrrrrrrr
2024-09-11 started high level circuit layout
2024-09-26 istfg Ishan
2024-09-30 dealt with the ops
2024-09-30 damn, the ops got hands
2024-09-30 womp womp
2024-09-30 idk anymore man
2024-10-05 hi ishannnnnn
2024-10-06 gabagoo
2024-10-09 DRC go brrr (need to change text thickness)
2024-10-09 the liberal media doesn't want you that text height violations isn't realgit add .git add .git add .
2024-10-10 lakshay learns algebra + BOM
2024-10-11 aligned connector
2024-10-13 BOOM
2024-10-14 bom 2
2024-10-14 PA0 stanky leg
2024-10-14 gerb
2024-10-31 PERIPHERAL SOM V2 WAHOOOOOOOOOOOOOOOOOOOOOOOOO (IGNORE OLD PR) (#16)
    * moved to KiCAD 8
    * fixed mcu pins and moved revision history
    * started v2 changes
    * fixed SPI prot
    * wahoooooo
    * fixed symbols
2024-11-25 can+power layout
2024-11-25 and so it begins...
2024-11-29 wahoo?
2024-11-29 routing done mayhaps
2024-11-30 fixed LED traces
2024-11-30 better LED ordering + silkscreen stuff
2024-12-01 less via in pad
2024-12-07 addressed prat
2025-01-16 it's gerbing time
2025-01-20 i'm so dumb
2025-01-20 change max draw on iso dc-dc
2025-01-20 update ibom
2025-03-14 V2.1 (#17)
    * womp womp
    * woop woop
    * can+power layout
    * and so it begins...
    * wahoo?
    * routing done mayhaps
2025-03-17 mostly done with schematic
2025-03-18 wom womp
2025-03-30 skibbidi
2025-03-31 poop and farts
2025-04-02 ISHAN GAVE ME A 99
2025-04-11 stuff
2025-04-16 subcircuit layout done
2025-07-19 added TODO
2025-07-20 purge shit
2025-07-20 add back bild
2025-07-20 initial PP changes
2025-07-22 completed PP
2025-07-22 kinda add buck
2025-07-23 add LDO
2025-07-24 lower OVP
2025-07-24 add CAN
2025-07-25 add 5v power mux
2025-07-25 add USB
2025-07-28 control but micro
2025-07-29 prelim pin selection
2025-07-30 finish mcu breakouts
2025-07-30 populate conn
2025-07-30 twinkle
2025-07-31 all parts selected
2025-07-31 add IMON, change conn pinout
2025-07-31 add some footprints
2025-08-02 more stuff
2025-08-02 all footprints assigned
2025-08-02 update usb footprint
2025-08-03 CAN layout
2025-08-03 more layout
2025-08-03 buck + mux + ldo
2025-08-03 start adding mcu
2025-08-04 address some stuff
2025-08-04 erm hii
2025-08-04 smaller
2025-08-05 some lakshay fixes
2025-08-05 move pp and som connector
2025-08-11 add some lcsc parts
2025-08-11 more better
2025-08-11 place mcu/usb-uart
2025-08-11 more stuff (idk where this jumper is going)
2025-08-11 can't
2025-08-11 type shi
2025-08-12 boo lakshay
2025-08-12 WTF IS A SILKSCREEN OVERLAPPP
2025-08-12 half these warnings are fak
2025-08-13 not done routing
2025-08-13 initial routing
2025-08-14 rm colinear tracks
2025-08-14 move PP resistors to front, reduce rtn plane size
2025-08-14 silkscreen my opp
2025-08-14 more fixes
2025-08-15 brah why is this ignored
2025-08-15 software engineer attempts length matching (impossible)
2025-08-17 reroute uart, change leds to 0603
2025-08-17 LED lcsc p/n
2025-08-17 skill issue
2025-08-18 move analog filtering closer
2025-08-18 gerbs
2025-08-18 correct fab files + docs
2025-08-21 mounting hole dims
2025-08-21 fake ahh errors
2025-08-23 update lib
2025-08-23 Rev B (#19)
    * started
    * added TODO
    * Update README.md
    * purge shit
    * add back bild
    * initial PP changes
2025-08-27 ibom and stuff
2025-08-27 more
2025-08-27 condense
2025-08-27 bom qty
2025-09-20 added workflow and json
2025-09-20 added dispatch
2025-09-20 added on push
2025-09-20 please
2025-09-20 updated json and 3dmodel
2025-09-20 updated relative paths
2025-09-20 added github outputs
2025-09-20 only project file now ballin
2025-09-20 ok apparently thats not real LMAO
2025-09-20 added only proc on errors
2025-09-20 separated check from fail steps
2025-09-20 split steps
2025-09-20 continue on error
2025-09-27 new 3dmodel generator
2025-09-27 whoopsies didnt delete
2025-09-27 3dmodel check fix
2025-09-27 aight lets see
2025-09-27 auto mode
2025-09-27 no kicadcli
2025-09-27 apparently making the file fails wtf
2025-09-27 move to correct folder
2025-09-27 Add missing board STEP model
2025-09-27 added 3dshapes
2025-09-27 delete
2025-09-27 no update
2025-09-27 3dmodel works
2025-09-27 fix debian
2025-09-27 no cli
2025-11-04 add or gate for boot
2025-11-04 2 unrouted
2025-11-04 holy chopped 🥀
2025-11-05 add solder jumper for 3v3
2025-11-05 new prod files
