# Repository lhr-solar/PeripheralSOMPCB

File README.md:

# PeripheralSOMPCB
The Peripheral System-On-Module handles communication with SPI or I2C based ICs, along with various analog inputs on peripheral boards to send data on the vehicle CAN bus. Please refer to the [MCU pins sheet](https://utexas.sharepoint.com/:x:/r/sites/ENGR-LonghornRacing/_layouts/15/doc.aspx?sourcedoc=%7Bae949e00-1e0a-407f-a329-0fe6b0b1511b%7D&action=edit) to determine which pins can be used for each alternate function.

## BOM
[**BOM**](bom/PeripheralSOM.csv)  
[**IBOM**](bom/ibom.html)  

## PCB
)

## Schematic
[**PDF with all sheets**](docs/PeripheralSOM.pdf)

## KiCad design PeripheralSOM.kicad_pcb

Parts:
J4: 52465-2470; 524652470
LOGO2: LHRs; LHRs_LOGO
MH1, MH2, MH3, MH4: M3; MountingHole_3.2mm_M3_Pad_TopBottom

Connections:
+3.3V: J4.2; also elsewhere on the board
+24V_EXT: J4.24; also elsewhere on the board
/CAN_H: J4.22; also elsewhere on the board
/CAN_L: J4.20; also elsewhere on the board
/MCU/ADC1_IN7: J4.9; also elsewhere on the board
/MCU/ADC1_IN9: J4.11; also elsewhere on the board
/MCU/ADC1_IN10: J4.13; also elsewhere on the board
/MCU/ADC1_IN11: J4.15; also elsewhere on the board
/MCU/I2C1_SCL: J4.6; also elsewhere on the board
/MCU/I2C1_SDA: J4.4; also elsewhere on the board
/MCU/SPI1_MISO: J4.21; also elsewhere on the board
/MCU/SPI1_MOSI: J4.17; also elsewhere on the board
/MCU/SPI1_NSS: J4.19; also elsewhere on the board
/MCU/SPI1_SCK: J4.23; also elsewhere on the board
/MCU/SPI2_MISO: J4.14; also elsewhere on the board
/MCU/SPI2_MOSI: J4.16; also elsewhere on the board
/MCU/SPI2_NSS: J4.12; also elsewhere on the board
/MCU/SPI2_SCK: J4.18; also elsewhere on the board
/OPAMP1_VINP: J4.7; also elsewhere on the board
GND: J4.1, J4.3, J4.5; also elsewhere on the board
GNDA: J4.10; also elsewhere on the board
VDDA: J4.8; also elsewhere on the board

Notes on the sheet:
Board Notes
Graphics/Mounting
Changelog: - Change pp values to be 24V - Swap out buck converter for 24 - 5V converter - Spec LDO for a little bit higher current - Get rid of push button - Remove isolation - Swap out CAN chip for TCAN (noniso) - Add 5v power mux - Swap out Micro USB for USB-C - Swap out FTDI chip for SiLabs chip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
idk figure it out
Connector mates with 53307-2471 Consult README for pin usage guide *Always verify pin functions with CubeMX*
Daughterboard Connector

Parts:
C19: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C24: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: CFLT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
JP1: TRM; PinHeader_1x02_P2.54mm_Vertical
R4: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U4: TCAN337; TCAN337DCNR
U5: CDSOT23-T24CAN

Connections:
+3.3V: C19.1, C24.1, R4.1, U4.3 (VCC); also elsewhere on the board
/CAN/CAN1_RX: U4.4 (RXD); also elsewhere on the board
/CAN/CAN1_TX: U4.1 (TXD); also elsewhere on the board
/CAN/FAULT: R4.2, R5.1, U4.5 (FAULT)
/CAN_H: R7.1, U4.7 (CANH), U5.1 (CAN_H); also elsewhere on the board
/CAN_L: JP1.2 (B), U4.6 (CANL), U5.2 (CAN_L); also elsewhere on the board
GND: C19.2, C24.2, D3.1 (K), U4.2 (GND), U5.3 (GND); also elsewhere on the board
unnamed: D3.2 (A), R5.2
unnamed: JP1.1 (A), R7.2

Notes on the sheet:
CAN Bus Termination
CAN Transceiver
CAN Bus Protection

Parts:
C7, C11, C12, C14, C15, C16, C17, C36: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C22: 12p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CR1, CR2: D5V0P4UR6SO-7
FB1, FB4: FerriteBead; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: SWD; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
R10, R29, R33: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RST; SW_TL3365AF180QG
SW2: BOOT; SW_CJS-1200TA
U1: STM32L431CBTx; LQFP-48_7x7mm_P0.5mm
U9: 74AHC1G32; SOT-23-5
Y1: 8M; Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm

Connections:
+3.3V: C13.1, C14.1, C16.1, C17.1, C36.1, CR1.5, CR2.5, FB4.1, J1.1, R29.1, SW2.1 (A), U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U9.5 (VCC); also elsewhere on the board
/CAN/CAN1_RX: U1.45 (PB8); also elsewhere on the board
/CAN/CAN1_TX: U1.46 (PB9); also elsewhere on the board
/LEDs/LED1: U1.17 (PA7); also elsewhere on the board
/LEDs/LED2: U1.29 (PA8); also elsewhere on the board
/LEDs/LED3: U1.38 (PA15); also elsewhere on the board
/LEDs/LED_HB: U1.22 (PB11); also elsewhere on the board
/MCU/ADC1_IN7: U1.12 (PA2); also elsewhere on the board
/MCU/ADC1_IN9: U1.14 (PA4); also elsewhere on the board
/MCU/ADC1_IN10: U1.15 (PA5); also elsewhere on the board
/MCU/ADC1_IN11: U1.16 (PA6); also elsewhere on the board
/MCU/ADC1_IN16: U1.19 (PB1); also elsewhere on the board
/MCU/BOOT0: R10.1, U1.44 (PH3)
/MCU/BOOT_GPIO: R33.1, U1.40 (PB4), U9.2
/MCU/BOOT_SW: SW2.2 (B), U9.1
/MCU/I2C1_SCL: U1.42 (PB6); also elsewhere on the board
/MCU/I2C1_SDA: U1.43 (PB7); also elsewhere on the board
/MCU/NRST: C11.1, R29.2, SW1.1, U1.7 (NRST)
/MCU/OSC_IN: C21.1, U1.5 (PH0), Y1.1
/MCU/OSC_OUT: C22.1, U1.6 (PH1), Y1.2
/MCU/SPI1_MISO: CR2.6, U1.32 (PA11); also elsewhere on the board
/MCU/SPI1_MOSI: CR2.4, U1.33 (PA12); also elsewhere on the board
/MCU/SPI1_NSS: CR2.1, U1.18 (PB0); also elsewhere on the board
/MCU/SPI1_SCK: CR2.3, U1.39 (PB3); also elsewhere on the board
/MCU/SPI2_MISO: CR1.1, U1.27 (PB14); also elsewhere on the board
/MCU/SPI2_MOSI: CR1.6, U1.28 (PB15); also elsewhere on the board
/MCU/SPI2_NSS: CR1.3, U1.25 (PB12); also elsewhere on the board
/MCU/SPI2_SCK: CR1.4, U1.21 (PB10); also elsewhere on the board
/MCU/SWCLK: J1.2, U1.37 (PA14)
/MCU/SWDIO: J1.4, U1.34 (PA13)
/MCU/USART1_RX: U1.31 (PA10); also elsewhere on the board
/MCU/USART1_TX: U1.30 (PA9); also elsewhere on the board
/OPAMP1_VINP: U1.10 (PA0); also elsewhere on the board
GND: C11.2, C13.2, C14.2, C16.2, C17.2, C21.2, C22.2, C36.2, CR1.2, CR2.2, FB1.1, J1.3, R33.2, SW1.2, SW2.3 (C), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U9.3 (GND); also elsewhere on the board
GNDA: C7.2, C12.2, C15.2, FB1.2, U1.8 (VSSA); also elsewhere on the board
unnamed: R10.2, U9.4
VDDA: C7.1, C12.1, C15.1, FB4.2, U1.9 (VDDA); also elsewhere on the board

Notes on the sheet:
PC13-15 can source max 3mA
add list of alternate functions
VDD Bypass Caps
System memory (bootloader)
The crystal and caps have to be as close to the uC as possible and no traces should go underneath these components or connections.
NC OPAMP1_VOUT -> internally connected to ADC1_IN8
OR gate allows software (GPIO) to trigger bootloader
SPI Protection
CAN bootloader pins
VDDA Seperation
Bypass/Separation
Primary Pin Functions
NC OPAMP1_VINM (inverting input) -> using internal PGA
Reset Button
USART bootloader pins
Boot from...
SWD Connector
Mates with 0022013047
Boot Switch
VDDA Bypass Caps
Main flash (user code)

Parts:
D4: Heartbeat; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12: LED2; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13: LED1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D14: LED0; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6, R11, R17, R18: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
/LEDs/LED1: R18.1; also elsewhere on the board
/LEDs/LED2: R17.1; also elsewhere on the board
/LEDs/LED3: R6.1; also elsewhere on the board
/LEDs/LED_HB: R11.1; also elsewhere on the board
GND: D4.1 (K), D12.1 (K), D13.1 (K), D14.1 (K); also elsewhere on the board
unnamed: D4.2 (A), R11.2
unnamed: D12.2 (A), R6.2
unnamed: D13.2 (A), R17.2
unnamed: D14.2 (A), R18.2

Parts:
C3, C8, C10, C18, C34, C35: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C27, C28: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 3.3nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C26: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: MBR230S1F; D_SOD-123F
D7: 24V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: 3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9: PFLT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D11: BUCK; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
JP2: EN; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: 100uH; L_Coilcraft_MSS1246-XXX
R2: ROSC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R3: 16k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 332; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25, R28: 4.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32: 768; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1: 24V_EXT; TestPoint_Pad_1.0x1.0mm
TP2: 24V; TestPoint_Pad_1.0x1.0mm
TP3: 5V_BK; TestPoint_Pad_1.0x1.0mm
TP4: 5V_USB; TestPoint_Pad_1.0x1.0mm
TP6: 3V3; TestPoint_Pad_1.0x1.0mm
TP7, TP8: GND; TestPoint_Pad_1.0x1.0mm
U2: TPS5405DR
U3: LT1963AEST-3.3#TRPBF; SOT-223-3_TabPin2
U6: TPS2115ADRBR; VSON-8-1EP_3x3mm_P0.65mm_EP1.65x2.4mm

Connections:
+3.3V: JP2.2 (B), R26.1, TP6.1; also elsewhere on the board
+5V: C10.1, C26.1, R9.1, R32.1, U3.1 (IN), U6.7 (OUT)
+5V_BUCK: C8.1, C27.1, C34.1, C35.1, L1.2, TP3.1, U2.5 (VSENSE), U6.8 (IN1)
+5V_VBUS: C28.1, TP4.1, U6.6 (IN2); also elsewhere on the board
+24V: C3.1, C9.1, R25.1, R28.1, TP2.1, U2.2 (VIN); also elsewhere on the board
+24V_EXT: TP1.1; also elsewhere on the board
/PowerDist/FAULT: D9.1 (K); also elsewhere on the board
/PowerDist/ILIM: R8.1, U6.4 (ILIM)
/PowerDist/LDO_3V3: C18.1, JP2.1 (A), U3.3 (OUT)
/PowerDist/ROSC: R2.1, U2.3 (ROSC)
/PowerDist/STAT: D11.1 (K), R9.2, U6.1 (STAT)
GND: C3.2, C5.2, C8.2, C9.2, C10.2, C18.2, C26.2, C27.2, C28.2, C34.2, C35.2, D1.2 (A), D7.1 (K), D8.1 (K), R2.2, R3.2, R8.2, TP7.1, TP8.1, U2.7 (GND), U3.2 (GND), U6.3 (D1), U6.5 (GND), U6.9 (EXP); also elsewhere on the board
unnamed: C6.2, R3.1
unnamed: C4.2, D1.1 (K), L1.1, U2.8 (LX)
unnamed: D7.2 (A), R25.2
unnamed: D8.2 (A), R26.2
unnamed: D9.2 (A), R28.2
unnamed: D11.2 (A), R32.2
unnamed: C4.1, U2.1 (BOOT)
unnamed: C6.1, U2.6 (COMP)
unnamed: C5.1, U2.4 (SS)

Notes on the sheet:
Vin: 6.5v to 28v Vout: 4.85v to 5.15v
Testpoints
Cout > 28.8uF -> 30uF For 30uF, ESR < 120mΩ
Ripple current: 487mA (243.5 mA per cap) Ripple voltage: 125mV
Indicators
chat gave me these
i fucking hate math
Slow start time: (10nF * 0.8v)/2uA = 4ms
Max current: 1.5A
L: 92uH -> 100uH ΔIl: 0.33A DC load: 1.2A Peak current: 1.53A
Current Limit: 1.2A Overvoltage: ~27v Undervoltage: ~20v Use 1% resistors for closest values
5v Power Mux
Fault active low
Power Protection
24->5v Buck Converter
ILim(A) = 500/R 1.5A = 500/332
Prioritizes IN1 (Buck)
5->3.3v LDO
DNP for 120 kHz switching frequency

Parts:
C29: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C30, C32: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C31, C33: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D5: 1N5819HW; D_SOD-123
D6: SP0503BAHTG; SOT-143
J2: USB4215-03-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R14, R16: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U8: CP2102N-A02-GQFN24

Connections:
+3.3V: C30.1, C31.1, C32.1, C33.1, R21.1, U8.5 (VIO), U8.6 (VDD), U8.7 (VREGIN); also elsewhere on the board
+5V_VBUS: C29.1, D5.1 (K), D6.4 (K), R22.1; also elsewhere on the board
/MCU/USART1_RX: U8.21 (TXD); also elsewhere on the board
/MCU/USART1_TX: U8.20 (RXD); also elsewhere on the board
/USB/CC1: J2.A5 (CC1), R14.1
/USB/CC2: J2.B5 (CC2), R16.1
/USB/D+: D6.2 (K), J2.A6 (D+), J2.B6 (D+), U8.3 (D+)
/USB/D-: D6.3 (K), J2.A7 (D-), J2.B7 (D-), U8.4 (D-)
/USB/RST: R21.2, U8.9 (~RST)
/USB/VBUS: R22.2, R24.1, U8.8 (VBUS)
/USB/VBUS_IN: D5.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
GND: C29.2, C30.2, C31.2, C32.2, C33.2, D6.1 (A), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R14.2, R16.2, R24.2, U8.2 (GND), U8.25 (GND); also elsewhere on the board

Notes on the sheet:
CCx Pulldown
VREGIN Bypass
VDD Bypass
USB-C Port
UART_TX -> MCU_RX UART_RX <- MCU_TX
shift around for best layout
USB <-> UART
Voltage divider per datasheet pg. 9
USB Protection

Parts:
C1, C2: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C23: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2: TVS; D_SOD-323_HandSoldering
D10: TVS; D_SOD-123F
R1, R23, R27: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 45.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 590; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 2.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 402k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30: 24m; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R31: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
U7: LM76202QPWPRQ1

Connections:
+3.3V: R23.1; also elsewhere on the board
+24V: C2.1, C23.1, R1.1, U7.15 (OUT_1), U7.16 (OUT_2); also elsewhere on the board
+24V_EXT: C1.1, C20.1, D2.2 (A2), R12.1, U7.1 (IN_1), U7.2 (IN_2); also elsewhere on the board
/MCU/ADC1_IN16: D10.1 (K), R31.2; also elsewhere on the board
/PowerDist/FAULT: R1.2, U7.14 (~FLT); also elsewhere on the board
/PowerDist/PowerProtection/ILIM: R27.1, U7.11 (ILIM)
/PowerDist/PowerProtection/IMON: R30.1, R31.1, U7.10 (IMON)
/PowerDist/PowerProtection/MODE: R20.1, U7.6 (MODE)
/PowerDist/PowerProtection/OVP: R13.2, R15.1, U7.5 (OVP)
/PowerDist/PowerProtection/RTN: C25.2, R15.2, R20.2, R27.2, R30.2, U7.8 (RTN), U7.17 (EP)
/PowerDist/PowerProtection/SHDN: R23.2, U7.7 (~SHDN)
/PowerDist/PowerProtection/UVLO: R12.2, R13.1, U7.3 (UVLO)
GND: C1.2, C2.2, C20.2, C23.2, D2.1 (A1), D10.2 (A), U7.9 (GND); also elsewhere on the board
unnamed: C25.1, U7.12 (DVDT)

Notes on the sheet:
DNP until validated
OVP set to 27v for buck max voltage of 28v
ILim(A) = 12/R(k) 1.2A = 12/10kΩ
Current Monitoring
Set to circuit breaker (latchoff) Use 0 ohm resistor for auto-retry (540ms)
Under/Overvoltage Protection
RTN!=GND Conecting GND to RTN turns off RPP!
Pullups
Overcurrent Protection
Functional Mode Selection
20.88 ms ramp time
SHDN has weak internal pullup - pulled up to MCU voltage after initial power on
Typical gain: 78.28 uA/A Vout @ 1.3A = 2.407v R(imon) = 23.7 mΩ

Board: 4 copper layers, 53.5 x 37.8 mm, 116 parts (37 on the bottom side), 80 nets.

File docs/bom.csv:

"Reference","Value","Footprint","Qty","p/n"
"C1,C2,C9,C19,C26","1uF","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","5",""
"C3,C8,C10,C18,C20,C23,C29,C34,C35","10uF","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","9",""
"C4,C24,C27,C28,C31,C33","0.1uF","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","6",""
"C5","10nF","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","1",""
"C6","3.3nF","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","1",""
"C7,C11,C12,C14,C15,C16,C17,C25","100nF","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","8",""
"C13,C30,C32","4.7uF","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","3",""
"C21,C22","12p","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","2",""
"CR1,CR2","D5V0P4UR6SO-7","UTSVT_ICs:D5V0P4UR6SO-7","2",""
"D1","MBR230S1F","Diode_SMD:D_SOD-123F","1",""
"D2,D10","TVS","Diode_SMD:D_SOD-123F,Diode_SMD:D_SOD-323_HandSoldering","2",""
"D3","CFLT","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"D4","Heartbeat","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"D5","1N5819HW","Diode_SMD:D_SOD-123","1",""
"D6","SP0503BAHTG","Package_TO_SOT_SMD:SOT-143","1",""
"D7,TP2","24V","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,TestPoint:TestPoint_Pad_1.0x1.0mm","2",""
"D8,TP6","3V3","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,TestPoint:TestPoint_Pad_1.0x1.0mm","2",""
"D9","PFLT","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"D11","BUCK","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"D12","LED2","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"D13","LED1","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"D14","LED0","LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"FB1,FB4","FerriteBead","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","2",""
"J1","SWD","Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical","1",""
"J2","USB4215-03-A","Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal","1",""
"J4","52465-2470","UTSVT_Connectors:524652470","1",""
"JP1","TRM","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1",""
"L1","100uH","Inductor_SMD:L_Coilcraft_MSS1246-XXX","1",""
"LOGO2","LHRs","UTSVT_Logos:LHRs_LOGO","1",""
"MH1,MH2,MH3,MH4","M3","MountingHole:MountingHole_3.2mm_M3_Pad_TopBottom","4",""
"R1,R4,R9,R19,R23,R27,R29","10k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","7",""
"R2","ROSC","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R3","16k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R5,R6,R7,R11,R17,R18,R26","120","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","7",""
"R8","332","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R12","45.3k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R13","590","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R14,R16","5.1k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","2",""
"R15","2.1k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R20","402k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R21","1k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R22","22k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R24","47k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R25,R28","4.3k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","2",""
"R30","24m","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R31","100k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R32","768","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"SW1","RST","TL3365AF180QG:SW_TL3365AF180QG","1",""
"SW2","BOOT","CJS-1200TA:SW_CJS-1200TA","1",""
"TP1","24V_EXT","TestPoint:TestPoint_Pad_1.0x1.0mm","1",""
"TP3","5V_BK","TestPoint:TestPoint_Pad_1.0x1.0mm","1",""
"TP4","5V_USB","TestPoint:TestPoint_Pad_1.0x1.0mm","1",""
"TP7,TP8","GND","TestPoint:TestPoint_Pad_1.0x1.0mm","2",""
"U1","STM32L431CBTx","Package_QFP:LQFP-48_7x7mm_P0.5mm","1",""
"U2","TPS5405DR","UTSVT_Power:TPS5405DR","1",""
"U3","LT1963AEST-3.3#TRPBF","Package_TO_SOT_SMD:SOT-223-3_TabPin2","1",""
"U4","TCAN337","UTSVT_ICs:TCAN337DCNR","1",""
"U5","CDSOT23-T24CAN","UTSVT_ICs:CDSOT23-T24CAN","1",""
"U6","TPS2115ADRBR","Package_SON:VSON-8-1EP_3x3mm_P0.65mm_EP1.65x2.4mm","1",""
"U7","LM76202QPWPRQ1","UTSVT_Power:LM76202QPWPRQ1","1",""
"U8","CP2102N-A02-GQFN24","UTSVT_ICs:CP2102N-A02-GQFN24","1",""
"Y1","8M","Crystal:Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm","1",""
