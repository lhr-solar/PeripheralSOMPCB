File: PeripheralSOM.kicad_sch (KiCad schematic)
At the start: 7 parts, among them J4 52465-2470

Commit message: add IMON, change conn pinout
Connections:
- net +24V_EXT: now also J4.24; no longer J4.22
- net ADC1_IN10: now also J4.16; no longer J4.18
- net ADC1_IN11: now also J4.18; no longer J4.20
- net ADC1_IN7: now also J4.12; no longer J4.14
- net ADC1_IN9: now also J4.14; no longer J4.16
- net CAN_H: now also J4.22; no longer J4.13
- net CAN_L: now also J4.20; no longer J4.15
- net GND: now also J4.1, J4.3, J4.5; no longer J4.11, J4.24, J4.4
- net GNDA: now also J4.10; no longer J4.12
- net I2C1_SCL: now also J4.6; no longer J4.8
- net I2C1_SDA: now also J4.4; no longer J4.6
- net OPAMP1_VINP: now also J4.15; no longer J4.9
- net SPI2_MOSI: now also J4.9; no longer J4.5
- net SPI2_NSS: now also J4.13; no longer J4.1
- net SPI2_SCK: now also J4.11; no longer J4.3
- net VDDA: now also J4.8; no longer J4.10
Other:
- sheet PowerDist ports: added IMON_OUT; removed none
- note added: "Todo: - Move power/gnd to diff sides of conn - Part & Footprint selection - Add datasheet links for all Done: - Need to change pp values to be 24V - Swap out buck converter for 25 - 5V converter - Spec LDO for a little bit higher current - Get rid of push button - Remove isolation - Swap out CAN chip for TCAN (noniso) - Add 5v power mux - Swap out Micro USB for USB-C - Swap out FTDI chip for SiLa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"
- note removed: "Ext 24v -> Protected 24v -> 5v -> 3.3v"
- note removed: "Todo: - Move power/gnd to diff sides of conn - Connect IMON to MCU - Part & Footprint selection - Add datasheet links for all Done: - Need to change pp values to be 24V - Swap out buck converter for 25 - 5V converter - Spec LDO for a little bit higher current - Get rid of push button - Remove isolation - Swap out CAN chip for TCAN (noniso) - Add 5v power mux - Swap out Micro USB for USB-C - Swap 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"
- moved on the sheet: MH1, MH2, MH3, MH4

Commit message: add some footprints
Parts:
- LOGO2: footprint UTSVT_Logos:Hallock_Image_Small -> UTSVT_Logos:LHRs_LOGO
- MH1, MH2, MH3, MH4: footprint (none) -> MountingHole:MountingHole_3.2mm_M3_Pad_TopBottom
Other:
- note added: "Todo: - Footprint selection Done: - Need to change pp values to be 24V - Swap out buck converter for 25 - 5V converter - Spec LDO for a little bit higher current - Get rid of push button - Remove isolation - Swap out CAN chip for TCAN (noniso) - Add 5v power mux - Swap out Micro USB for USB-C - Swap out FTDI chip for SiLabs chip - Change all testpoints to pad testpoints - Double check pins for UA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"
- note removed: "Todo: - Move power/gnd to diff sides of conn - Part & Footprint selection - Add datasheet links for all Done: - Need to change pp values to be 24V - Swap out buck converter for 25 - 5V converter - Spec LDO for a little bit higher current - Get rid of push button - Remove isolation - Swap out CAN chip for TCAN (noniso) - Add 5v power mux - Swap out Micro USB for USB-C - Swap out FTDI chip for SiLa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"
Changed lines of the file:
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@@
 		)
 	)
-	(text "Todo:\n- Move power/gnd to diff sides of conn\n- Part & Footprint selection\n- Add datasheet links for all\nDone:\n- Need to change pp values to be 24V\n- Swap out buck converter for 25 - 5V converter\n- Spec LDO for a little bit higher current\n- Get rid of push button\n- Remove isolation\n- Swap out CAN chip for TCAN (noniso)\n- Add 5v power mux\n- Swap out Micro USB for USB-C\n- Swap out FTDI chip for SiLabs chip\n- Change all testpoints to pad testpoints\n- Double check pins for UART and CAN bootloader\n- Swap out 2 extra ADC pins for the better ones\n- CubeMX to try and get the internal STM32 PGA\n- Check over and redo MCU pins\n- Connect IMON to MCU\n\n"
+	(text "Todo:\n- Footprint selection\nDone:\n- Need to change pp values to be 24V\n- Swap out buck converter for 25 - 5V converter\n- Spec LDO for a little bit higher current\n- Get rid of push button\n- Remove isolation\n- Swap out CAN chip for TCAN (noniso)\n- Add 5v power mux\n- Swap out Micro USB for USB-C\n- Swap out FTDI chip for SiLabs chip\n- Change all testpoints to pad testpoints\n- Double check pins for UART and CAN bootloader\n- Swap out 2 extra ADC pins for the better ones\n- CubeMX to try and get the internal STM32 PGA\n- Check over and redo MCU pins\n- Connect IMON to MCU\n- Move power/gnd to diff sides of conn\n- Add datasheet links for all\n- Part selection\n"
 		(exclude_from_sim no)
 		(at 22.098 107.442 0)
@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "MountingHole:MountingHole_3.2mm_M3_Pad_TopBottom"
 			(at 138.43 85.725 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "UTSVT_Logos:Hallock_Image_Small"
+		(property "Footprint" "UTSVT_Logos:LHRs_LOGO"
 			(at 107.95 92.075 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "MountingHole:MountingHole_3.2mm_M3_Pad_TopBottom"
 			(at 128.27 85.725 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "MountingHole:MountingHole_3.2mm_M3_Pad_TopBottom"
 			(at 138.43 93.98 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "MountingHole:MountingHole_3.2mm_M3_Pad_TopBottom"
 			(at 128.27 93.98 0)
 			(effects

Commit message: sch notes
Other:
- note added: "Done: - Need to change pp values to be 24V - Swap out buck converter for 25 - 5V converter - Spec LDO for a little bit higher current - Get rid of push button - Remove isolation - Swap out CAN chip for TCAN (noniso) - Add 5v power mux - Swap out Micro USB for USB-C - Swap out FTDI chip for SiLabs chip - Change all testpoints to pad testpoints - Double check pins for UART and CAN bootloader - Swap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"
- note removed: "Todo: - Footprint selection Done: - Need to change pp values to be 24V - Swap out buck converter for 25 - 5V converter - Spec LDO for a little bit higher current - Get rid of push button - Remove isolation - Swap out CAN chip for TCAN (noniso) - Add 5v power mux - Swap out Micro USB for USB-C - Swap out FTDI chip for SiLabs chip - Change all testpoints to pad testpoints - Double check pins for UA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"
Changed lines of the file:
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@@
 		)
 	)
-	(text "Todo:\n- Footprint selection\nDone:\n- Need to change pp values to be 24V\n- Swap out buck converter for 25 - 5V converter\n- Spec LDO for a little bit higher current\n- Get rid of push button\n- Remove isolation\n- Swap out CAN chip for TCAN (noniso)\n- Add 5v power mux\n- Swap out Micro USB for USB-C\n- Swap out FTDI chip for SiLabs chip\n- Change all testpoints to pad testpoints\n- Double check pins for UART and CAN bootloader\n- Swap out 2 extra ADC pins for the better ones\n- CubeMX to try and get the internal STM32 PGA\n- Check over and redo MCU pins\n- Connect IMON to MCU\n- Move power/gnd to diff sides of conn\n- Add datasheet links for all\n- Part selection\n"
+	(text "Done:\n- Need to change pp values to be 24V\n- Swap out buck converter for 25 - 5V converter\n- Spec LDO for a little bit higher current\n- Get rid of push button\n- Remove isolation\n- Swap out CAN chip for TCAN (noniso)\n- Add 5v power mux\n- Swap out Micro USB for USB-C\n- Swap out FTDI chip for SiLabs chip\n- Change all testpoints to pad testpoints\n- Double check pins for UART and CAN bootloader\n- Swap out 2 extra ADC pins for the better ones\n- CubeMX to try and get the internal STM32 PGA\n- Check over and redo MCU pins\n- Connect IMON to MCU\n- Move power/gnd to diff sides of conn\n- Add datasheet links for all\n- Part selection\n- Footprint selection\n"
 		(exclude_from_sim no)
 		(at 22.098 107.442 0)

Commit message: more layout
Parts:
- LOGO1: footprint UTSVT_Logos:Hallock_Image_Small -> UTSVT_Logos:Hallock_Image_Tiny
Changed lines of the file:
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@@
 			)
 		)
-		(property "Footprint" "UTSVT_Logos:Hallock_Image_Small"
+		(property "Footprint" "UTSVT_Logos:Hallock_Image_Tiny"
 			(at 107.95 83.82 0)
 			(effects

Commit message: address some stuff
Parts:
- J4: Manufacturer_Name Molex -> (none); Mouser Part Number 538-52465-2470 -> (none); Mouser Price/Stock https://www.mouser.co.uk/ProductDetail/Molex/52465-2470?qs=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 -> (none)
Changed lines of the file:
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@@
-			)
-		)
-		(property "Mouser Part Number" "538-52465-2470"
-			(at 165.1 530.48 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left top)
-				(hide yes)
-			)
-		)
-		(property "Manufacturer_Name" "Molex"
-			(at 165.1 730.48 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left top)
-				(hide yes)
 			)
 		)
@@
 			(effects
 				(font
-					(size 1.27 1.27)
-				)
-				(justify left top)
-				(hide yes)
-			)
-		)
-		(property "Mouser Price/Stock" "https://www.mouser.co.uk/ProductDetail/Molex/52465-2470?qs=sEN%2FkO1EG6Yhu4DkZwbE7Q%3D%3D"
-			(at 165.1 630.48 0)
-			(effects
-				(font

Commit message: not done routing
Connections:
- net ADC1_IN10: now also J4.13; no longer J4.16
- net ADC1_IN11: now also J4.15; no longer J4.18
- net ADC1_IN7: now also J4.9; no longer J4.12
- net ADC1_IN9: now also J4.11; no longer J4.14
- net OPAMP1_VINP: now also J4.7; no longer J4.15
- net SPI1_MISO: now also J4.21; no longer J4.17
- net SPI1_MOSI: now also J4.17; no longer J4.19
- net SPI1_NSS: now also J4.19; no longer J4.23
- net SPI1_SCK: now also J4.23; no longer J4.21
- net SPI2_MISO: now also J4.14; no longer J4.7
- net SPI2_MOSI: now also J4.16; no longer J4.9
- net SPI2_NSS: now also J4.12; no longer J4.13
- net SPI2_SCK: now also J4.18; no longer J4.11
Changed lines of the file:
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@@
 		)
 	)
-	(label "ADC1_IN9"
-		(at 180.34 48.26 180)
+	(label "SPI2_MOSI"
+		(at 180.34 45.72 180)
 		(effects
 			(font
@@
 		)
 	)
-	(label "SPI2_MOSI"
-		(at 132.08 53.34 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left bottom)
-		)
-	)
-	(label "ADC1_IN7"
-		(at 180.34 50.8 180)
+	(label "SPI2_SCK"
+		(at 180.34 43.18 180)
 		(effects
 			(font
@@
 	)
 	(label "SPI1_MOSI"
-		(at 132.08 40.64 0)
+		(at 132.08 43.18 0)
 		(effects
 			(font
@@
 		)
 	)
-	(label "SPI2_SCK"
-		(at 132.08 50.8 0)
+	(label "ADC1_IN10"
+		(at 132.08 48.26 0)
 		(effects
 			(font
@@
 		)
 	)
-	(label "ADC1_IN11"
-		(at 180.34 43.18 180)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right bottom)
-		)
-	)
 	(label "I2C1_SDA"
 		(at 180.34 60.96 180)
@@
 	)
 	(label "OPAMP1_VINP"
-		(at 132.08 45.72 0)
+		(at 132.08 55.88 0)
 		(effects
 			(font
@@
 		)
 	)
-	(label "SPI2_NSS"
-		(at 132.08 48.26 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left bottom)
-		)
-	)
 	(label "I2C1_SCL"
 		(at 118.11 29.21 180)
@@
 		)
 	)
-	(label "ADC1_IN10"
-		(at 180.34 45.72 180)
+	(label "ADC1_IN11"
+		(at 132.08 45.72 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
+	(label "SPI2_NSS"
+		(at 180.34 50.8 180)
 		(effects
 			(font
@@
 	)
 	(label "SPI1_MISO"
-		(at 132.08 43.18 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left bottom)
+		(at 132.08 38.1 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
+	(label "SPI2_MISO"
+		(at 180.34 48.26 180)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right bottom)
 		)
 	)
 	(label "SPI1_SCK"
-		(at 132.08 38.1 0)
+		(at 132.08 35.56 0)
 		(effects
 			(font
@@
 		)
 	)
-	(label "SPI2_MISO"
-		(at 132.08 55.88 0)
+	(label "ADC1_IN7"
+		(at 132.08 53.34 0)
 		(effects
 			(font
@@
 	)
 	(label "SPI1_NSS"
-		(at 132.08 35.56 0)
+		(at 132.08 40.64 0)
 		(effects
 			(font
@@
 		(effects
 			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
+	(label "ADC1_IN9"
+		(at 132.08 50.8 0)
+		(effects
+			(font

Commit message: more fixes
Parts:
- removed LOGO1: Dr. Hallock, UTSVT_Logos:Hallock_Image_Tiny, symbol utsvt_misc:Logo_Placeholder
Changed lines of the file:
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@@
 	(symbol
 		(lib_id "utsvt_misc:Logo_Placeholder")
-		(at 107.95 93.98 0)
+		(at 111.76 90.17 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "LOGO2"
-			(at 107.95 90.17 0)
+			(at 111.76 86.36 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "LHRs"
-			(at 111.506 93.98 0)
+			(at 115.316 90.17 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "UTSVT_Logos:LHRs_LOGO"
-			(at 107.95 92.075 0)
+			(at 111.76 88.265 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 107.95 92.075 0)
+			(at 111.76 88.265 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Graph footprint placeholder"
-			(at 107.95 93.98 0)
+			(at 111.76 90.17 0)
 			(effects
 				(font
@@
 					(unit 1)
 				)
-			)
-		)
-	)
-	(symbol
-		(lib_id "utsvt_misc:Logo_Placeholder")
-		(at 107.95 85.725 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom no)
-		(on_board yes)
-		(dnp no)
-		(property "Reference" "LOGO1"
-			(at 107.95 81.915 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Value" "Dr. Hallock"
-			(at 111.506 85.725 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-			)
-		)
-		(property "Footprint" "UTSVT_Logos:Hallock_Image_Tiny"
-			(at 107.95 83.82 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" ""
-			(at 107.95 83.82 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Graph footprint placeholder"
-			(at 107.95 85.725 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(instances
-			(project "BPS-Leader"
-				(path "/c248b171-df31-4e8a-afb6-607fa2df334b"
-					(reference "LOGO1")
-					(unit 1)
-				)
-			)
-			(project "BPS-PeripheralSOM"
-				(path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d"
-					(reference "LOGO1")
-					(unit 1)
-				)
