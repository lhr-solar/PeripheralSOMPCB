File: CAN.kicad_sch (KiCad schematic)
At the start: 16 parts, among them J5 CAN_Out, U17 ADM3055E, U18 CDSOT23-T24CAN

Commit message: made PCB camp changes
Connections:
- net GND1: no longer J5.4 (Pin_4)
- net GND_ISO_Out: now also J5.4 (Pin_4)
- net 5_In renamed 5V_Ext
Other:
- moved on the sheet: C33, C34, C35, C36

Commit message: added datasheets for passive components
Parts:
- U18: Mouser Part Number 652-CDSOT23-T24CAN -> (none); P/N (none) -> CDSOT23-T24CAN
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 152.4 71.12 0)
+    (property "Datasheet" "https://product.tdk.com/system/files/dam/doc/product/emc/emc/beads/catalog/beads_automotive_signal_mmz2012_en.pdf" (at 152.4 71.12 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.524 1.524)) hide)
     )
-    (property "Datasheet" "" (at 207.01 66.04 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/54/cdsot23_t24can_q-1534349.pdf" (at 207.01 66.04 0)
       (effects (font (size 1.524 1.524)) hide)
     )
-    (property "Mouser Part Number" "652-CDSOT23-T24CAN " (at 207.01 66.04 0)
+    (property "Mouser Part Number" "" (at 207.01 66.04 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "CDSOT23-T24CAN" (at 207.01 66.04 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 157.48 74.93 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/40/AVX_X7RDielectric_777024-1853642.pdf" (at 157.48 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 152.4 78.74 0)
+    (property "Datasheet" "https://product.tdk.com/system/files/dam/doc/product/emc/emc/beads/catalog/beads_automotive_signal_mmz2012_en.pdf" (at 152.4 78.74 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 255.27 91.44 0)
+    (property "Datasheet" "https://tools.molex.com/pdm_docs/sd/430450612_sd.pdf" (at 255.27 91.44 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 48.895 78.74 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/40/AVX_X7RDielectric_777024-1853642.pdf" (at 48.895 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: fixed can connectors to use GND1 instead of GND_ISO_OUT
Connections:
- net GND1: now also J5.4 (Pin_4)
- net GND_ISO_Out: no longer J5.4 (Pin_4)
Changed lines of the file:
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@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 262.89 91.44) (xy 264.795 91.44))
+  (wire (pts (xy 262.89 91.44) (xy 267.97 91.44))
     (stroke (width 0) (type default))
   )
@@
   )
   (label "V_ISO_In" (at 135.89 67.31 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "GND_ISO_Out" (at 264.795 91.44 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:GND1") (at 267.97 91.44 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR030" (at 267.97 97.79 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND1" (at 271.78 92.71 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 267.97 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 267.97 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "BPS-PeripheralSOM"
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/1d0c269d-60cf-499b-bfd2-5087981d6678"
+          (reference "#PWR030") (unit 1)
+        )
+      )

Commit message: cleaned up silkscreen, removed unused tracks and vias, and moved canout connectorto main schematic
Parts:
- removed J5: CAN_Out, Connector_Molex:Molex_Micro-Fit_3.0_43045-0612_2x03_P3.00mm_Vertical, symbol Connector_Generic:Conn_02x03_Odd_Even
Changed lines of the file:
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@@
   (junction (at 193.04 93.98) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 217.17 91.44) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 175.26 71.12) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 74.93 74.93) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 219.71 93.98) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 157.48 71.12) (diameter 0) (color 0 0 0 0)
   )
@@
   )
   (junction (at 92.71 80.01) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 224.79 74.93) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 190.5 91.44) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 241.935 93.98) (xy 250.19 93.98))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 69.215 81.28) (xy 69.215 82.55))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 262.89 88.9) (xy 264.795 88.9))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 182.88 73.66) (xy 186.69 73.66))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 222.25 91.44) (xy 217.17 91.44))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 134.62 76.2) (xy 129.54 76.2))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 224.79 88.9) (xy 250.19 88.9))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 132.08 71.12) (xy 129.54 71.12))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 262.89 91.44) (xy 267.97 91.44))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 204.47 91.44) (xy 204.47 87.63))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 262.89 93.98) (xy 264.795 93.98))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 134.62 81.28) (xy 134.62 83.82))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 219.71 93.98) (xy 222.885 93.98))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 92.71 80.01) (xy 93.98 80.01))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 242.57 91.44) (xy 250.19 91.44))
-    (stroke (width 0) (type default))
-  )
   (polyline (pts (xy 109.22 55.245) (xy 109.22 112.395))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 132.08 67.31) (xy 157.48 67.31))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 224.79 74.93) (xy 224.79 88.9))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "CAN_H" (at 264.795 88.9 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "CAN_H" (at 222.25 91.44 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "CAN_L" (at 222.885 93.98 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "GND_ISO_Out" (at 134.62 78.74 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "CAN_L" (at 241.935 93.98 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (hierarchical_label "SILENT" (shape input) (at 90.805 95.25 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (hierarchical_label "5V_Ext" (shape input) (at 242.57 91.44 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-  )
   (symbol (lib_id "Device:C_Small") (at 74.93 78.74 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/1d0c269d-60cf-499b-bfd2-5087981d6678"
           (reference "C26") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "power:GND1") (at 267.97 91.44 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR030" (at 267.97 97.79 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND1" (at 271.78 92.71 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 267.97 91.44 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 267.97 91.44 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/1d0c269d-60cf-499b-bfd2-5087981d6678"
-          (reference "#PWR030") (unit 1)
         )
       )
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "Connector_Generic:Conn_02x03_Odd_Even") (at 255.27 91.44 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "J5" (at 256.54 83.82 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "CAN_Out" (at 256.54 86.36 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Connector_Molex:Molex_Micro-Fit_3.0_43045-0612_2x03_P3.00mm_Vertical" (at 255.27 91.44 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://tools.molex.com/pdm_docs/sd/430450612_sd.pdf" (at 255.27 91.44 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (pin "3")
-    (pin "4")
-    (pin "5")
-    (pin "6")
-    (instances
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/1d0c269d-60cf-499b-bfd2-5087981d6678"
-          (reference "J5") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "power:GNDPWR") (at 264.795 93.98 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR022" (at 264.795 99.06 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GNDPWR" (at 264.668 99.06 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 264.795 95.25 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 264.795 95.25 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/1d0c269d-60cf-499b-bfd2-5087981d6678"
-          (reference "#PWR022") (unit 1)
-        )
-      )

Commit message: added more part numbers
Parts:
- R34: P/N (none) -> CRCW08050000Z0EAC
- R35: P/N (none) -> CRCW080559R0FKEA
- U17: Mouser Part Number (none) -> 584-ADM3055EBRIZ; P/N (none) -> ADM3055EBRIZ
- U18: Mouser Part Number (none) -> 652-CDSOT23-T24CAN
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 204.47 83.82 0)
+    (property "Datasheet" "https://www.vishay.com/docs/20035/dcrcwe3.pdf" (at 204.47 83.82 0)
       (effects (font (size 1.27 1.27)) hide)
     )
     (property "Mouser Part Number" "71-CRCW080559R0FKEA" (at 204.47 83.82 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "CRCW080559R0FKEA" (at 204.47 83.82 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (property "Datasheet" "https://www.mouser.com/datasheet/2/609/ADM3055E-3057E-1509677.pdf" (at 111.76 82.55 0)
       (effects (font (size 1.524 1.524)) hide)
+    )
+    (property "Mouser Part Number" "584-ADM3055EBRIZ" (at 111.76 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "ADM3055EBRIZ" (at 111.76 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
     )
     (pin "1")
@@
       (effects (font (size 1.524 1.524)) hide)
     )
-    (property "Mouser Part Number" "" (at 207.01 66.04 0)
+    (property "Mouser Part Number" "652-CDSOT23-T24CAN" (at 207.01 66.04 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 142.24 99.06 0)
+    (property "Datasheet" "https://www.vishay.com/docs/28773/crcwce3.pdf" (at 142.24 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "P/N" "CRCW08050000Z0EAC" (at 142.24 99.06 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: added part numbers
Parts:
- C33, C38: P/N (none) -> 0805YC106KAT2A
- C34, C35, C39: Mouser Part Number 80-C0805C104K3R -> 80-C0805C104M5R; P/N (none) -> C0805C104M5RACTU
- C36: Mouser Part Number 80-C0805X103K1R3316 -> 80-C0805C104M5R; P/N (none) -> C0805C104M5RACTU
- C37: Mouser Part Number 80-C0805C224J1RECTU -> 80-C0805C224K5R; P/N (none) -> C0805C224K5RACTU
- C40: Mouser Part Number 80-C0805X103K1R3316 -> 80-C0805C103J5R; P/N (none) -> C0805C103J5RACTU
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 74.93 78.74 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Mouser Part Number" "80-C0805X103K1R3316 " (at 74.93 78.74 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 74.93 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "80-C0805C104M5R" (at 74.93 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "C0805C104M5RACTU" (at 74.93 78.74 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 175.26 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Mouser Part Number" "80-C0805X103K1R3316 " (at 175.26 74.93 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 175.26 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "80-C0805C103J5R" (at 175.26 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "C0805C103J5RACTU" (at 175.26 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 57.785 78.74 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Mouser Part Number" "80-C0805C104K3R " (at 57.785 78.74 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 57.785 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "80-C0805C104M5R" (at 57.785 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "C0805C104M5RACTU" (at 57.785 78.74 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 167.64 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Mouser Part Number" "80-C0805C104K3R " (at 167.64 74.93 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 167.64 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "80-C0805C104M5R" (at 167.64 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "C0805C104M5RACTU" (at 167.64 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 147.32 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Mouser Part Number" "80-C0805C224J1RECTU " (at 147.32 74.93 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 147.32 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "80-C0805C224K5R" (at 147.32 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "C0805C224K5RACTU" (at 147.32 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 69.215 78.74 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Mouser Part Number" "80-C0805C104K3R " (at 69.215 78.74 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 69.215 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "80-C0805C104M5R" (at 69.215 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "C0805C104M5RACTU" (at 69.215 78.74 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Mouser Part Number" "80-C0805C106K8RAUTO " (at 157.48 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "0805YC106KAT2A" (at 157.48 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "P/N" "0805YC106KAT2A" (at 48.895 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
