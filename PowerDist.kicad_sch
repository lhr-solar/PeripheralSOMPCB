File: PowerDist.kicad_sch (KiCad schematic)
At the start: 15 parts, among them Q1 Q_PMOS_GSD, U2 RI3-0505S, U3 LD1117-3.3_SOT223

Commit message: v1.2 initial changes
Parts:
- removed U2: RI3-0505S, UTSVT_ICs:RI3_DC_Converter, symbol utsvt-power-regulators:RI3-1205S
- added P1: 1769205132, UTSVT_Power:LGA-7, symbol utsvt-power-regulators:176920512
- C21: footprint UTSVT_Passive:C_2220_5750Metric -> Capacitor_SMD:C_0805_2012Metric
Connections:
- net +5V: now also P1.5 (+VOUT)
- net 5V_Ferrite: now also Q1.3 (D); no longer Q1.2 (S)
- net GND: now also P1.3 (-VOUT), P1.4 (-VOUT)
- net GNDPWR: now also P1.1 (-VIN), P1.2 (-VIN)
- net at C21.1, TP1.1: now also Q1.2 (S), P1.6 (+VIN), P1.7 (+VIN); no longer Q1.3 (D)
Other:
- moved on the sheet: C22, C23, Q1, TP1, TP3, TP4, U3

Commit message: fix power dist from can
Parts:
- removed C22, C23: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed U3: LD1117-3.3_SOT223, Package_TO_SOT_SMD:SOT-223-3_TabPin2, symbol Regulator_Linear:LD1117S33TR_SOT223
- added C4: 100uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added C5, C6: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added Q1: PBSS4330X,135, Package_TO_SOT_THT:TO-39-3, symbol Transistor_BJT:2N2219
- added R3: 100, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added U6: LP5912-3.3DRV, Package_SON:WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias, symbol Regulator_Linear:LP5912-3.3DRV
Connections:
- net +3.3V: now also C5.1, U6.1 (OUT)
- net +5V: now also Q1.3 (C), R3.1
- net GND: now also C4.2, C5.2, C6.2, U6.5 (GND), U6.7 (EP)
- new net: C4.1, Q1.2 (B), R3.2
- new net: C6.1, Q1.1 (E), U6.4 (EN), U6.6 (IN)
- no-connect marks 0 -> 1
Other:
- note removed: "D"
- note removed: "G"
- note removed: "S"

Commit message: add new isolated power:
Parts:
- removed P1: 1769205132, UTSVT_Power:LGA-7, symbol utsvt-power-regulators:176920512
- added P2: 1769405141, UTSVT_Power:1769405141, symbol utsvt-power-regulators:1769405141
Connections:
- net +5V: now also P2.5 (+VOUT)
- net GND: now also P2.4 (-VOUT)
- net GNDPWR: now also P2.1 (-VIN)
- net at C21.1, Q1.2 (S), TP1.1: now also P2.2 (+VIN)
Changed lines of the file:
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@@
 (kicad_sch (version 20230121) (generator eeschema)
   (paper "A4")
-  (junction (at 149.86 117.475) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 132.715 92.71) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 35.56 131.445) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 132.715 102.235) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 254.635 92.71) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 80.01 83.82) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 158.75 117.475) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 227.965 80.01) (diameter 0) (color 0 0 0 0)
   )
@@
   )
   (junction (at 170.18 117.475) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 149.86 71.755) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 165.1 71.755) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 149.86 117.475) (xy 149.86 121.285))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 221.615 80.01) (xy 227.965 80.01))
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 158.75 117.475) (xy 170.18 117.475))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 177.8 117.475) (xy 170.18 117.475))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 158.75 117.475) (xy 170.18 117.475))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 96.52 102.235) (xy 96.52 107.315))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 140.97 92.71) (xy 140.97 71.755))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 227.965 80.01) (xy 240.665 80.01))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 149.86 71.755) (xy 152.4 71.755))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 132.715 101.6) (xy 132.715 102.235))
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 141.605 92.71) (xy 141.605 119.38))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 96.52 91.44) (xy 96.52 93.345))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 140.97 71.755) (xy 149.86 71.755))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 35.56 131.445) (xy 35.56 133.985))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 132.715 92.71) (xy 140.97 92.71))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 35.56 128.905) (xy 35.56 131.445))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 149.86 117.475) (xy 140.97 117.475))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 191.77 76.2) (xy 191.77 80.01))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 132.715 102.235) (xy 140.97 102.235))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 113.665 102.235) (xy 132.715 102.235))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 141.605 119.38) (xy 152.4 119.38))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 132.715 93.98) (xy 132.715 92.71))
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 152.4 119.38) (xy 152.4 117.475))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 80.01 83.82) (xy 80.01 86.995))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 156.21 117.475) (xy 158.75 117.475))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 241.935 85.09) (xy 240.665 85.09))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 132.715 92.71) (xy 141.605 92.71))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 80.01 102.235) (xy 96.52 102.235))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 152.4 117.475) (xy 149.86 117.475))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 140.97 102.235) (xy 140.97 117.475))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (text "Power GND\n(External)" (at 141.605 122.555 0)
+  (text "Power GND\n(External)" (at 97.155 107.315 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (text "5V to 3.3V" (at 207.645 61.595 0)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "Collector" (at 193.675 80.01 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
         (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
           (reference "C8") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "power:GNDPWR") (at 149.86 121.285 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR022" (at 149.86 126.365 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GNDPWR" (at 149.9616 125.1966 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 149.86 122.555 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 149.86 122.555 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "BPS-Leader"
+        (path "/c248b171-df31-4e8a-afb6-607fa2df334b/00000000-0000-0000-0000-00005c29e573"
+          (reference "#PWR022") (unit 1)
+        )
+      )
+      (project "BPS-PeripheralSOM"
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
+          (reference "#PWR027") (unit 1)
         )
       )
@@
     )
   )
-  (symbol (lib_id "utsvt-power-regulators:176920512") (at 151.13 117.475 90) (unit 1)
+  (symbol (lib_id "utsvt-power-regulators:1769405141") (at 151.13 117.475 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "P1" (at 163.195 93.345 90)
+    (property "Reference" "P2" (at 162.56 93.345 90)
       (effects (font (size 1.524 1.524)) (justify right))
     )
-    (property "Value" "1769205132" (at 163.195 95.885 90)
+    (property "Value" "1769405141" (at 162.56 95.885 90)
       (effects (font (size 1.524 1.524)) (justify right))
     )
-    (property "Footprint" "UTSVT_Power:LGA-7" (at 147.32 117.475 0)
+    (property "Footprint" "UTSVT_Power:1769405141" (at 147.32 117.475 0)
       (effects (font (size 1.27 1.27) italic) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/ProductDetail/Wurth-Elektronik/1769205132?qs=T%252BzbugeAwjiUHVVyhCL5qA%3D%3D" (at 147.32 117.475 0)
+    (property "Datasheet" "https://www.mouser.com/ProductDetail/Wurth-Elektronik/1769405141?qs=T%252BzbugeAwjggRc36WtB4Aw%3D%3D" (at 147.32 117.475 0)
       (effects (font (size 1.27 1.27) italic) hide)
     )
     (pin "1")
     (pin "2")
-    (pin "3")
     (pin "4")
     (pin "5")
-    (pin "6")
-    (pin "7")
-    (instances
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
-          (reference "P1") (unit 1)
-        )
-      )
+    (pin "8")
+    (instances
+      (project "BPS-PeripheralSOM"
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
+          (reference "P2") (unit 1)
+        )
+      )

Commit message: started layout
Parts:
- Q1: footprint Package_TO_SOT_THT:TO-39-3 -> Package_TO_SOT_SMD:SOT-89-3
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Package_TO_SOT_THT:TO-39-3" (at 218.44 77.47 0)
+    (property "Footprint" "Package_TO_SOT_SMD:SOT-89-3" (at 218.44 77.47 0)
       (effects (font (size 1.27 1.27) italic) (justify left) hide)
     )

Commit message: relayed out usb chips
Parts:
- TP1, TP2, TP3, TP4: footprint TestPoint:TestPoint_Keystone_5005-5009_Compact -> TestPoint:TestPoint_Pad_1.5x1.5mm
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "TestPoint:TestPoint_Keystone_5005-5009_Compact" (at 174.625 70.485 0)
+    (property "Footprint" "TestPoint:TestPoint_Pad_1.5x1.5mm" (at 174.625 70.485 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "TestPoint:TestPoint_Keystone_5005-5009_Compact" (at 172.72 120.015 0)
+    (property "Footprint" "TestPoint:TestPoint_Pad_1.5x1.5mm" (at 172.72 120.015 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "TestPoint:TestPoint_Keystone_5005-5009_Compact" (at 108.585 103.505 0)
+    (property "Footprint" "TestPoint:TestPoint_Pad_1.5x1.5mm" (at 108.585 103.505 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "TestPoint:TestPoint_Keystone_5005-5009_Compact" (at 112.395 81.28 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "TestPoint:TestPoint_Pad_1.5x1.5mm" (at 112.395 81.28 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: revise layout for closer gndpwr plane
Parts:
- D6: value SD12_SOD323 -> DESD5V0U1BA; P/N PESD15VL1BA,115 -> DESD5V0U1BA
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "SD12_SOD323" (at 82.55 92.71 90)
+    (property "Value" "DESD5V0U1BA" (at 82.55 92.71 90)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/916/PESD15VL1BA-3162292.pdf" (at 80.01 90.805 0)
+    (property "Datasheet" "https://www.mouser.com/ProductDetail/Diodes-Incorporated/DESD5V0U1BA-7?qs=wtVJq%252Be05r98RUWcs2LyvQ%3D%3D" (at 80.01 90.805 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "P/N" "PESD15VL1BA,115" (at 80.01 90.805 90)
+    (property "P/N" "DESD5V0U1BA" (at 80.01 90.805 90)
       (effects (font (size 1.27 1.27)) hide)
     )
