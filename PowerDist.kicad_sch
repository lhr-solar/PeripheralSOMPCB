File: PowerDist.kicad_sch (KiCad schematic)
At the start: 32 parts, among them U3 TPS562231DRLR, U4 CME0303S3C, U7 LM76202QPWPRQ1

Commit message: pp foot
Parts:
- U7: footprint UTSVT_ICs:LM76202QPWPRQ1 -> UTSVT_ICs:SOP65P640X120-17N
Changed lines of the file:
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@@
 			)
 		)
-		(property "Datasheet" "https://www.mouser.com/ProductDetail/TDK/MLZ2012N100LT000?qs=%2FPzWLGNeQ%252BhBF9df2MjAZQ%3D%3D"
+		(property "Datasheet" "~"
 			(at 194.31 120.65 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.mouser.com/ProductDetail/TDK/MLZ2012M3R3HT000?qs=%2FPzWLGNeQ%252BgwPKJam21HNA%3D%3D"
+		(property "Datasheet" "~"
 			(at 87.63 119.38 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "UTSVT_ICs:LM76202QPWPRQ1"
+		(property "Footprint" "UTSVT_ICs:SOP65P640X120-17N"
 			(at 97.79 59.69 0)
 			(effects
@@
 			)
 		)
-		(property "Description" ""
+		(property "Description" "12V, 450W Discrete Bidirectional TVS Diode, SOD-323"
 			(at 54.61 68.58 0)
 			(effects

Commit message: ppppp
Parts:
- R22: value R -> 100k; Mouser Part Number (none) -> 71-CRCW0805100KFKEAC; P/N (none) -> CRCW0805100KFKEAC
- R23: value R -> 10K; Mouser Part Number (none) -> 71-CRCW080510K0FKEAC; P/N (none) -> CRCW080510K0FKEAC
- R5: value R -> 3k
Other:
- note added: "Ovlo ~ 13.45V Uvlo ~ 10.34"
Changed lines of the file:
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@@
 	(wire
 		(pts
-			(xy 250.19 135.89) (xy 250.19 134.62)
+			(xy 250.19 139.7) (xy 250.19 134.62)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 245.11 135.89) (xy 250.19 135.89)
+			(xy 245.11 139.7) (xy 250.19 139.7)
 		)
 		(stroke
@@
 		)
 	)
+	(text "Ovlo ~ 13.45V\nUvlo ~ 10.34"
+		(exclude_from_sim no)
+		(at 42.672 94.996 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+		)
+	)
 	(text "3.3V -> 3.3V (Isolated)"
 		(exclude_from_sim no)
@@
 	)
 	(label "fault"
-		(at 245.11 135.89 0)
+		(at 245.11 139.7 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		(on_board yes)
 		(dnp no)
-		(fields_autoplaced yes)
 		(property "Reference" "R22"
-			(at 63.5 88.8999 0)
+			(at 62.738 89.0016 0)
 			(effects
 				(font
@@
 			)
 		)
-		(property "Value" "R"
-			(at 63.5 91.4399 0)
+		(property "Value" "100k"
+			(at 62.738 91.313 0)
 			(effects
 				(font
@@
 			)
 		)
+		(property "Mouser Part Number" "71-CRCW0805100KFKEAC"
+			(at 60.96 90.17 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "P/N" "CRCW0805100KFKEAC"
+			(at 60.96 90.17 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 	)
 	(symbol
+		(lib_id "Device:R")
+		(at 60.96 69.85 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(property "Reference" "R23"
+			(at 63.5 69.215 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(property "Value" "10K"
+			(at 63.5 71.755 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(property "Footprint" "Resistor_SMD:R_0805_2012Metric"
+			(at 59.182 69.85 90)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" "~"
+			(at 60.96 69.85 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Resistor"
+			(at 60.96 69.85 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Mouser Part Number" "71-CRCW080510K0FKEAC"
+			(at 60.96 69.85 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "P/N" "CRCW080510K0FKEAC"
+			(at 60.96 69.85 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(pin "2"
+		)
+		(instances
+			(project "BPS-PeripheralSOM"
+				(path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
+					(reference "R23")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
 		(lib_id "power:+3.3V")
 		(at 208.28 118.11 0)
@@
 			)
 		)
-		(property "Value" "R"
+		(property "Value" "3k"
 			(at 63.5 81.2799 0)
 			(effects
@@
 					(unit 1)
 				)
-			)
-		)
-	)
-	(symbol
-		(lib_id "Device:R")
-		(at 60.96 69.85 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(fields_autoplaced yes)
-		(property "Reference" "R23"
-			(at 63.5 68.5799 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-			)
-		)
-		(property "Value" "R"
-			(at 63.5 71.1199 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-			)
-		)
-		(property "Footprint" "Resistor_SMD:R_0805_2012Metric"
-			(at 59.182 69.85 90)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" "~"
-			(at 60.96 69.85 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Resistor"
-			(at 60.96 69.85 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "1"
-		)
-		(pin "2"
-		)
-		(instances
-			(project "BPS-PeripheralSOM"
-				(path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
-					(reference "R23")
-					(unit 1)
-				)

Commit message: more cap filtering
Parts:
- added C25: 47uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
Connections:
- net 12V_Ext: now also C25.1
- net GNDPWR: now also C25.2
Changed lines of the file:
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@@
 	(paper "A4")
 	(junction
+		(at 54.61 72.39)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
+	(junction
 		(at 52.07 116.84)
 		(diameter 0)
@@
 	)
 	(junction
+		(at 41.91 64.77)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
+	(junction
 		(at 49.53 64.77)
 		(diameter 0)
@@
 	(wire
 		(pts
-			(xy 224.79 111.76) (xy 224.79 116.84)
+			(xy 224.79 113.03) (xy 224.79 116.84)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 44.45 64.77) (xy 49.53 64.77)
+			(xy 39.37 64.77) (xy 41.91 64.77)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 41.91 64.77) (xy 49.53 64.77)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 236.22 134.62) (xy 236.22 133.35)
 		)
@@
 	(wire
 		(pts
-			(xy 236.22 111.76) (xy 236.22 116.84)
+			(xy 236.22 113.03) (xy 236.22 116.84)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 41.91 72.39) (xy 54.61 72.39)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 38.1 114.3) (xy 38.1 116.84)
 		)
@@
 	)
 	(rectangle
-		(start 34.29 106.68)
+		(start 30.48 106.68)
 		(end 114.3 151.13)
 		(stroke
@@
 	)
 	(rectangle
-		(start 35.56 52.832)
-		(end 167.386 97.282)
+		(start 219.964 106.68)
+		(end 266.954 151.384)
+		(stroke
+			(width 0)
+			(type default)
+		)
+		(fill
+			(type none)
+		)
+	)
+	(rectangle
+		(start 30.226 53.086)
+		(end 162.052 97.536)
 		(stroke
 			(width 0)
@@
 	(text "Max draw: 2.2A"
 		(exclude_from_sim no)
-		(at 42.164 99.06 0)
+		(at 37.846 99.314 0)
 		(effects
 			(font
@@
 	(text "Max draw: 2A"
 		(exclude_from_sim no)
-		(at 40.64 153.162 0)
+		(at 36.83 153.162 0)
 		(effects
 			(font
@@
 	(text "12V -> 3.3V (Unisolated)"
 		(exclude_from_sim no)
-		(at 46.736 105.41 0)
+		(at 42.926 105.664 0)
 		(effects
 			(font
@@
 	(text "Ovlo ~ 13.45V\nUvlo ~ 10.34"
 		(exclude_from_sim no)
-		(at 42.672 94.996 0)
+		(at 37.846 95.25 0)
 		(effects
 			(font
@@
 	(text "Vout = .6 * (1 + (Rfbt / Rfbb))\n3.3V = .6 * (1 + (45.3 / 10))"
 		(exclude_from_sim no)
-		(at 51.054 148.336 0)
+		(at 46.99 148.844 0)
 		(effects
 			(font
@@
 	(text "Max draw: 227 mA"
 		(exclude_from_sim no)
-		(at 132.588 152.908 0)
+		(at 131.064 153.416 0)
 		(effects
 			(font
@@
 	(hierarchical_label "12V_Ext"
 		(shape input)
-		(at 44.45 64.77 180)
+		(at 39.37 64.77 180)
 		(fields_autoplaced yes)
 		(effects
@@
 	)
 	(symbol
+		(lib_id "Device:C")
+		(at 41.91 68.58 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(property "Reference" "C25"
+			(at 44.704 67.818 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(property "Value" "47uF"
+			(at 44.45 70.358 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
+			(at 42.8752 72.39 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" "~"
+			(at 41.91 68.58 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Unpolarized capacitor"
+			(at 41.91 68.58 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Mouser Part Number" ""
+			(at 41.91 68.58 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "P/N" ""
+			(at 41.91 68.58 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(pin "2"
+		)
+		(instances
+			(project "BPS-PeripheralSOM"
+				(path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
+					(reference "C25")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
 		(lib_id "Connector:TestPoint")
 		(at 224.79 63.5 90)
@@
 	(symbol
 		(lib_id "power:+3.3V")
-		(at 236.22 111.76 0)
+		(at 236.22 113.03 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR017"
-			(at 236.22 115.57 0)
+			(at 236.22 116.84 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "+3.3V"
-			(at 236.601 107.3658 0)
+			(at 236.601 108.6358 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 236.22 111.76 0)
+			(at 236.22 113.03 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 236.22 111.76 0)
+			(at 236.22 113.03 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"+3.3V\""
-			(at 236.22 111.76 0)
+			(at 236.22 113.03 0)
 			(effects
 				(font
@@
 	(symbol
 		(lib_id "power:+12V")
-		(at 224.79 111.76 0)
+		(at 224.79 113.03 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#PWR044"
-			(at 224.79 115.57 0)
+			(at 224.79 116.84 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "+12V"
-			(at 224.79 107.95 0)
+			(at 224.79 109.22 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 224.79 111.76 0)
+			(at 224.79 113.03 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 224.79 111.76 0)
+			(at 224.79 113.03 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"+12V\""
-			(at 224.79 111.76 0)
+			(at 224.79 113.03 0)
 			(effects
 				(font

Commit message: layout go brrrrrrrrrr
Parts:
- C20: value 12nF -> 100nF; Mouser Part Number (none) -> 80-C0805C104M5R; P/N (none) -> C0805C104M5RACTU
Connections:
- net 12V_Ext: now also R22.1; no longer R23.1
- net 3.3V_Iso: no longer L1.2, R19.1, TP2.1
- net OVP: now also R23.1; no longer R22.1
- net RTN: now also R23.2; no longer R22.2
- net UVLO: now also R22.2; no longer R23.2
- new net 3V3_Uniso: L1.2, R19.1, TP2.1
Other:
- note added: "Inrush current limited to 54mA"
- note removed: "Inrush current limited to .5A"
- moved on the sheet: R22, R23

Commit message: add pp sheet
Parts:
- removed C20: 100nF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed C23, C25: 47uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed D2: SD12_SOD323, Diode_SMD:D_SOD-323, symbol Diode:SD12_SOD323
- removed R22, R4: 100k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed R23, R27: 10K, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed R24: 5.36k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed R5: 3k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed U7: LM76202QPWPRQ1, UTSVT_ICs:SOP65P640X120-17N, symbol utsvt-chips:LM76202QPWPRQ1
Connections:
- no-connect marks 3 -> 0
Other:
- added sheet PowerProtection (PowerProtection.kicad_sch)
- note added: "Current limit = 1.2A"
- note removed: "Current lim(A) = 12/Rilim(k) 2.3A = 12/5.36k ohms"
- note removed: "RTN!=GND Conecting GND to RTN turns off RPP!"

Commit message: damn, the ops got hands
Connections:
- net 3V3_Uniso: no longer L1.2, R19.1, TP2.1
- net 3.3V_Iso renamed 3V3_Bus
- net 3V3_Bus: now also L1.2, R19.1, TP2.1
Changed lines of the file:
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@@
 		)
 	)
-	(hierarchical_label "3V3_Uniso"
+	(hierarchical_label "3V3_Bus"
 		(shape output)
 		(at 100.33 114.3 0)
@@
 		)
 	)
-	(hierarchical_label "3.3V_Iso"
+	(hierarchical_label "3V3_Bus"
 		(shape output)
 		(at 132.08 120.65 180)
@@
 		)
 	)
-	(hierarchical_label "3V3_Uniso"
+	(hierarchical_label "3V3_Bus"
 		(shape output)
 		(at 207.01 59.69 0)
